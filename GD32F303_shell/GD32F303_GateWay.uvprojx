# Keil uVision project GD32F303_GateWay.uvprojx, settings and files
target GateWay (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303_GateWay +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__FPU_PRESENT
  c include: .\Library\Firmware\GD32F30x_standard_peripheral\Include;.\Library\Firmware\CMSIS;.\Library\Firmware\CMSIS\GD\GD32F30x\Include;.\Hardware\Include;.\Hardware\APP\SI4463\inc;.\Hardware\APP\WIFI;.\Hardware;.\Hardware\shell
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ./Hardware/: gd32f30x_it.c main.c systick.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/TIMER/: timer.c
    ./Hardware/KEY/: key.c
    ./Hardware/GPIO/: gpio.c
    ./Hardware/USART/: usart_shell.c
  group SHELL
    ./Hardware/shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
  group CMSIS
    ./Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group StartUp
    ./Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group GD32F30x_Lib
    ./Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
